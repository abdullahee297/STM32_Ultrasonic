# IAR project Backup of fleet_tracker.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ; STM32F4xx\Include\; application\; drivers\; STM32F4xx_StdPeriph_Driver\Include\; STM32F4xx_StdPeriph_Driver\inc\; STM32F4_Discovery\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rvm.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: LinkerScript\fleet_tracker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group application
    application/: gps.c gps.h gsm.c gsm.h
  group drivers
    drivers/: console.c console.h defines.h general.c general.h Int_ADC.c Int_ADC.h menu.cpp menu.h TIM2.c TIM2.h tim7.c tim7.h tm_stm32f4_gpio.c tm_stm32f4_gpio.h tm_stm32f4_gps.c tm_stm32f4_gps.h tm_stm32f4_gsm.c tm_stm32f4_gsm.h tm_stm32f4_lis302dl_lis3dsh.c tm_stm32f4_lis302dl_lis3dsh.h tm_stm32f4_pwm.c tm_stm32f4_pwm.h tm_stm32f4_servo.c tm_stm32f4_servo.h tm_stm32f4_spi.c tm_stm32f4_spi.h tm_stm32f4_timer_properties.c tm_stm32f4_timer_properties.h tm_stm32f4_usart.c tm_stm32f4_usart.h uart.c uart.h
  group startup
    startup/: startup_stm32f4xx.s system_stm32f4xx.c
  group STM32F4_Discovery
    STM32F4_Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group user
    user/: main.c stm32f4xx_it.c
